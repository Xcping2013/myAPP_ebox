# Keil uVision project stm32f10x.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ebox +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\ebox_STM32F1\ebox\hardware\cortex-m3;..\ebox_STM32F1\ebox\hardware\cortex-m3\Peripherals;..\ebox_STM32F1\ebox\core;..\ebox_STM32F1\component;..\ebox_STM32F1\component\edriver;..\ebox_STM32F1\component\apps;..\ebox_STM32F1\mcuLib\stm32f10x\libraries\STM32F10x_StdPeriph_Driver\inc;..\ebox_STM32F1\mcuLib\stm32f10x\libraries\CMSIS\CM3\CoreSupport;..\ebox_STM32F1\component\FreeModbus\port;..\ebox_STM32F1\component\FreeModbus\modbus\ascii;..\ebox_STM32F1\component\FreeModbus\modbus\rtu;..\ebox_STM32F1\component\FreeModbus\modbus\tcp;..\ebox_STM32F1\component\FreeModbus\modbus\include;..\ebox_STM32F1\component\ddc;..\ebox_STM32F1\component\stepMotor;..\ebox_STM32F1\component\cnc;..\stm32f10x_mdk;..\ebox_STM32F1\component\edriver\SFUD\sfud\inc;..\ebox_STM32F1\component\edriver\WiFi;..\USMART;..\SYSTEM
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start_code
    ../eBox_STM32F1/mcuLib/stm32f10x/libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s startup_stm32f10x_md.s
  group CMSIS
    ../eBox_STM32F1/mcuLib/stm32f10x/libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group libraries
    ../eBox_STM32F1/mcuLib/stm32f10x/libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group eboxFun
    ../eBox_STM32F1/ebox/core/stdFun/: big_little.c crc.c ebox_mem.c ebox_printf.c fifo.c itoa.c math_misc.c util.c Dstring.cpp list.cpp new.cpp print.cpp random.cpp ringbuf.cpp sort.cpp WString.cpp
  group ebox_core
    ../eBox_STM32F1/ebox/core/: ebox_core.cpp ebox_init.cpp
  group ebox_mcu
    ../eBox_STM32F1/ebox/hardware/cortex-m3/Peripherals/: ebox_3steper.cpp ebox_analog.cpp ebox_can.cpp ebox_dac.cpp ebox_dma.cpp ebox_encoder.cpp ebox_exti.cpp ebox_gpio.cpp ebox_i2c.cpp ebox_iflash.cpp ebox_in_capture.cpp ebox_pwm.cpp ebox_rtc.cpp ebox_slave_spi.cpp ebox_softi2c.cpp ebox_softspi.cpp ebox_spi.cpp ebox_step_motor.cpp ebox_timer.cpp ebox_uart.cpp ebox_wdg.cpp
    ../eBox_STM32F1/ebox/hardware/cortex-m3/: dma.cpp ebox_it.cpp mcu.cpp object.cpp rcc.cpp
  group SYSTEM
    ../SYSTEM/: sys.c usart.cpp
  group user
    ./: system_stm32f10x.c nvic.cpp main_myStr.cpp
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group ebox_driver
    ../eBox_STM32F1/component/edriver/: 74HC595.cpp ads1118.cpp ADS7816.cpp ADS8866.cpp AM2315.cpp at24c02.cpp at45db.cpp BMP280-3.3.cpp Button.cpp colorled.cpp dht11.cpp ds18b20.cpp DS3231.cpp enc28j60.cpp encoder.cpp fm25v.cpp FT800.cpp GP2Y1051.cpp INA219.cpp ir_decoder.cpp ir_encoder.cpp key_dm.cpp L3G4200D.cpp lcd_1.8.cpp LCD1602.cpp LED.cpp led_segment.cpp lsm303dhlc.cpp LTC1446.cpp LTC2943.cpp Max7456.cpp MCP23017.cpp mmc_sd.cpp MPU6050.CPP Nokia5110.cpp NRF24L01.cpp OLED_4spi.cpp OLED_i2c.cpp parallel_gpio.cpp PCA9685.cpp si4432.cpp sx1278.cpp TingATCmd.cpp TLC59711.cpp TM1637.cpp TM1638.cpp TSL2561.cpp ultrasonic_wave.cpp USR_GM3.cpp w25x16.cpp w5500.cpp ws2812.cpp WS2812B.cpp
  group ebox_sfud
    ../eBox_STM32F1/component/edriver/SFUD/ebox/: ebox_sfud_port.cpp
    ../eBox_STM32F1/component/edriver/SFUD/sfud/src/: sfud_sfdp.c sfud.c
    ../eBox_STM32F1/component/edriver/SFUD/sfud/port/: sfud_port.c
  group ebox_wifi
    ../eBox_STM32F1/component/edriver/WiFi/: ESP8266.cpp esp8266_tcp.cpp esp8266_udp.cpp
  group ebox_apps
    ../eBox_STM32F1/component/apps/: calendar.cpp color_convert.cpp EventGpio.cpp EventIo.cpp spiBridge.cpp
  group example
    ../eBox_STM32F1/example/1.digital/: 1.gpio_write.cpp 2.button.cpp 3.EventGpioTest.cpp
    ../eBox_STM32F1/example/2.analog/: 1.analog_read.cpp 2.analog_write.cpp
    ../eBox_STM32F1/example/3.pwm/: 1.pwm.cpp 2.colorled.cpp 3.pwm&remap.cpp
    ../eBox_STM32F1/example/4.exti/: 1.exti.cpp 2.exti.cpp
    ../eBox_STM32F1/example/5.uart/: 1.helloWorld.cpp 2.random.cpp 3.random_no_repeat.cpp 4.send&recv_interrupt.cpp 5.uart3.cpp 6.TcInterrupt.cpp 7.RxInterrupt.cpp 8.get_cpu_info.cpp 9.printf.cpp
    ../eBox_STM32F1/example/6.timer/: 1.timer1.cpp 2.timer2.cpp
    ../eBox_STM32F1/example/7.wdg/: 1.iwdg.cpp
    ../eBox_STM32F1/example/8.rtc/: 1.rtc_basic.cpp 2.rtc_clock.cpp 3.calendar.cpp
    ../eBox_STM32F1/example/9.spi/: 1.w25x16.cpp 2.max7456.cpp 3.ltc1446.cpp 4.si4432_rx_tx.cpp
    ../eBox_STM32F1/example/10.i2c/: 1.24c02.cpp 2.ds3231.cpp 3.l3g4200d.cpp 4.lsm303dhlc.cpp 5.mpu6050.cpp
    ../eBox_STM32F1/example/11.in_capture/: 1.simple_event.cpp 2.complex_event.cpp 3.multi_complex_pulse.cpp
    ../eBox_STM32F1/example/12.定时器正交解码/: 32.定时器正交解码.cpp
    ../eBox_STM32F1/example/13.can/: 1.can_tx.cpp 2.can_rx.cpp
    ../eBox_STM32F1/example/14.usb_device/usb_serial/: 1.usb_serial.cpp
    ../eBox_STM32F1/example/14.usb_device/USB_msd_sd/: 1.usb_msd_sd.cpp 1.usb_msd_sd_main.cpp
    ../eBox_STM32F1/example/14.usb_device/usb_midi/: 1.usb_midi.cpp
    ../eBox_STM32F1/example/14.usb_device/usb_hid/: 1.usb_hid.cpp 2.usb_mouse.cpp 3.usb_keyboard.cpp 4.usb_mouse_keyboard.cpp 5.usb_hid_no_blocking.cpp
    ../eBox_STM32F1/example/14.usb_device/usb_audio/: 1.usb_audio.cpp
    ../eBox_STM32F1/example/27.pid/: 1.basic.cpp 2.电机控制.cpp 3.AutoTune.cpp
    ../eBox_STM32F1/example/31.sfud/: 1.sfud_demo.cpp
    ../eBox_STM32F1/example/32.内部flash读写/: 1.flash.cpp
